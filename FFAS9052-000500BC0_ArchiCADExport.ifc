Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2021-05-11T10:05:19
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: 20190808_0900(x64) - Exporter 19.2.20.24 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort
FlowDirection: SINK
Pset_DistributionPortPipe - PortNumber: 1; ConnectionType: WELDED
MEPPortPipe - ProfileShape: ROUND; OuterDiameter: 15 mm; ConnectorDiameter: 15 mm; NominalWidth: 15 mm; NominalHeight: 15 mm

# IfcEnergyConversionDevice: Acacia In-wall Rain Shower Head With Arm, FFAS9052-000500BC0:Acacia In-wall Rain Shower Head With Arm:3934
In: Level 1
Pset_ManufacturerTypeInformation - ModelReference: Acacia In-wall Rain Shower Head With Arm; Manufacturer: American Standard; ProductionYear: 2021
Pset_DistributionFlowElementCommon - Reference: Acacia In-wall Rain Shower Head With Arm
Constraints - Elevation: 0 mm
Dimensions - Area: 0.0637785 m2; Volume: 0.00101813 m3
Identity Data - Mark: 1
Mechanical - System Classification: Hydronic Supply
Other - AssetIdentifier: n/a; BarCode: Please Record On Commissioning.; Category: Plumbing Fixtures; Family: FFAS9052-000500BC0: Acacia In-wall Rain Shower Head With Arm; Family and Type: FFAS9052-000500BC0: Acacia In-wall Rain Shower Head With Arm; InstallationDate: Please Record On Commissioning.; SerialNumber: Please Record On Commissioning.; Type: FFAS9052-000500BC0: Acacia In-wall Rain Shower Head With Arm; Type Id: FFAS9052-000500BC0: Acacia In-wall Rain Shower Head With Arm; WarrantyStartDate: Please Record On Commissioning.
Phasing - Phase Created: New Construction
Constraints(Type) - Default Elevation: 0 mm
Data(Type) - ConnectionSize: n/a; FlowRate: n/a; InstallationType: n/a; ProductCategory: Showers & Shower Systems (50); ProductGroup: Rain Shower kit (04); ProductWeight: n/a; StyleSegment: n/a; SubCategory: Showers (51)
Identity Data(Type) - Assembly Code: D2010700; Description: Acacia In-wall Rain Shower Head With Arm; Keynote: N13; Manufacturer: American Standard; Model: Acacia In-wall Rain Shower Head With Arm; OmniClass Number: 23.45.05.14.17; OmniClass Title: Showers; Type Comments: FFAS9052-000500BC0; Type Name: Acacia In-wall Rain Shower Head With Arm; URL: https://www.americanstandard-apac.com/
Model Properties(Type) - _Author: JY; _AuthorizedBy: bimstore; _BimSpecGuid: 0; _BSBibleVersion: 16; _CreatedBy: https://www.bimstore.co; _CurrentRevision: 1; _DistributedBy: https://www.bimstore.co; _ObjectUserGuide: https://www.bimstore.co/products/ffas9052-000500bc0/document/object-user-guide; BIMObjectName: AmericanStandard_RainShowerkit_Acacia_(FFAS9052-000500BC0); NBSDescription: Shower fittings package; NBSNote: n/a; NBSObjectName: American Standard - Shower fittings package; NBSOfficeMasterTag: n/a; NBSReference: 45-35-70/330
Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; ClassificationName: Uniclass2015; ClassificationValue: Pr_40_20_87_75; CodePerformance: n/a; Color: n/a; Constituents: n/a; CreatedBy: https://www.americanstandard-apac.com/; CreatedOn: 2021-03-01T09:00:00; DocumentationCertificates: https://www.bimstore.co/products/ffas9052-000500bc0/document/product-certificates; DocumentationInstallationGuide: https://www.bimstore.co/products/ffas9052-000500bc0/document/installation-guide; DocumentationLiterature: https://www.bimstore.co/products/ffas9052-000500bc0/document/product-literature; DocumentationMaintenance: https://www.bimstore.co/products/ffas9052-000500bc0/document/maintenance-information; DocumentationTechnical: https://www.bimstore.co/products/ffas9052-000500bc0/document/technical-data-sheet; DurationUnit: Years; ExpectedLife: 0; Family Name: FFAS9052-000500BC0; Features: n/a; Finish: n/a; Grade: n/a; ManufacturerName: American Standard; Material: n/a; ModelNumber: FFAS9052-000500BC0; ModelReference: Acacia In-wall Rain Shower Head With Arm; ProductionYear: 2021; ReferencedStandard: n/a; ReplacementCost: n/a; Shape: n/a; Size: n/a; TypeName: Acacia In-wall Rain Shower Head With Arm; WarrantyDescription: n/a; WarrantyDurationLabor: 0; WarrantyDurationParts: 0; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: https://www.americanstandard-apac.com/; WarrantyGuarantorParts: https://www.americanstandard-apac.com/
AC_Pset_RenovationAndPhasing - Renovation Status: New
MEP_Proxy - MEP_InsShow: no
